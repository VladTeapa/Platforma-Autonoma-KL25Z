# Keil uVision project ProiectLicenta.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ProiectLicenta +hex
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./: Main.c Motoare.c PortsSetup.c Camera.c SistemDecizional.c Uart.c PID.c SenzoriDistanta.c
  group inc
    ./: Motoare.h Defines.h PortsSetup.h Camera.h SistemDecizional.h Uart.h PID.h SenzoriDistanta.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.5.0
